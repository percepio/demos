# IAR project Project.ewp, settings and files
configuration B-L475E-IOT01 (ARM, debug)
  General.OGChipSelectEditMenu: STM32L475VG ST STM32L475VG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32L475xx; USE_HAL_DRIVER; USE_STM32L475E_IOT01
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include; ..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc; ..\..\..\..\..\Drivers\BSP\B-L475E-IOT01; ..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\Drivers\BSP\Components\hts221; ..\..\..\..\..\Drivers\BSP\Components\lps22hb; ..\..\..\..\..\Drivers\BSP\Components\lis3mdl; ..\..\..\..\..\Drivers\BSP\Components\lsm6dsl; ..\Src\CrashCatcher\Core\src; ..\Src\CrashCatcher\include; ..\Src\DFM\cloudports\ITM\config; ..\Src\DFM\cloudports\ITM\include; ..\Src\DFM\config; ..\Src\DFM\include; ..\Src\DFM\kernelports\FreeRTOS\include; ..\Src\TraceRecorder\config; ..\Src\TraceRecorder\include; ..\Src\TraceRecorder\streamports\RingBuffer\config; ..\Src\TraceRecorder\streamports\RingBuffer\include; ..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\Src\DFM\storageports\Dummy\include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Inc
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32l475xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../../../../../UsageExamples/: 01_tracerecorder_kernel_tracing.c 02_tracerecorder_data_logging.c 10_dfm_crash_alert.c 11_dfm_custom_alert.c 12_dfm_stack_corruption_alert.c 13_dfm_stopwatch_alert.c 14_dfm_taskmonitor_alert.c
    ../Src/: main.c
  group Drivers/BSP/B-L475E-IOT01
    ../../../../../Drivers/BSP/B-L475E-IOT01/: stm32l475e_iot01.c stm32l475e_iot01_accelero.c stm32l475e_iot01_gyro.c stm32l475e_iot01_hsensor.c stm32l475e_iot01_magneto.c stm32l475e_iot01_psensor.c stm32l475e_iot01_qspi.c stm32l475e_iot01_tsensor.c
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/hts221/: hts221.c
    ../../../../../Drivers/BSP/Components/lis3mdl/: lis3mdl.c
    ../../../../../Drivers/BSP/Components/lps22hb/: lps22hb.c
    ../../../../../Drivers/BSP/Components/lsm6dsl/: lsm6dsl.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dfsdm.c stm32l4xx_hal_dma.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_qspi.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
  group EWARM
    ./: startup_stm32l475xx.s
    ../Src/: stm32l4xx_it.c
  group FreeRTOS
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Inc/: FreeRTOSConfig.h
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Percepio/CrashCatcher
    ../Src/CrashCatcher/Core/src/: CrashCatcher.c CrashCatcher_armv7m.c
  group Percepio/DFM
    ../Src/DFM/: dfm.c dfmAlert.c dfmCloud.c dfmCrashCatcher.c dfmEntry.c dfmRetainedMemory.c dfmSession.c dfmStopwatch.c dfmStorage.c dfmTaskMonitor.c
    ../Src/DFM/cloudports/ITM/: dfmCloudPort.c
    ../Src/DFM/kernelports/FreeRTOS/: dfmKernelPort.c
    ../Src/DFM/storageports/Dummy/: dfmStoragePort.c
  group Percepio/TraceRecorder
    ../Src/TraceRecorder/: trcAssert.c trcCounter.c trcDependency.c trcDiagnostics.c trcEntryTable.c trcError.c trcEvent.c trcEventBuffer.c trcExtension.c trcHardwarePort.c trcHeap.c trcInternalEventBuffer.c trcInterval.c trcISR.c trcKernelPort.c trcMultiCoreEventBuffer.c trcObject.c trcPrint.c trcRunnable.c trcStackMonitor.c trcStateMachine.c trcStaticBuffer.c trcStreamingRecorder.c trcString.c trcTask.c trcTaskMonitor.c trcTimestamp.c
    ../Src/TraceRecorder/streamports/RingBuffer/: trcStreamPort.c
  group Percepio/TraceRecorder/config
    ../Src/TraceRecorder/config/: trcConfig.h trcKernelPortConfig.h
    ../Src/TraceRecorder/streamports/RingBuffer/config/: trcStreamPortConfig.h
